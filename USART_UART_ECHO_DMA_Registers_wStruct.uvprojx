# Keil uVision project USART_UART_ECHO_DMA_Registers_wStruct.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART_UART_ECHO_DMA_Registers_wStruct
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\USART_UART_ECHO_DMA_Registers_wStruct.sct
  group Source Group 1
    ./: main.c USART_UART_DMA.c RCC_Config.c GPIO_fun.c main.h USART_UART_DMA.h RCC_Config.h GPIO_fun.h
software components: CMSIS:CORE 5.4.0, Compiler:Event Recorder 1.4.0, Device:Startup 1.0.0
